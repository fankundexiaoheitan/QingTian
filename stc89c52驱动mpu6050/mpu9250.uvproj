# Keil uVision project mpu9250.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: mpu9250 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c my_IIC.c my_IIC.h MPU_6050.c MPU_6050.h USART.c USART.h oled.h oled.c codetab.h Timer.c Timer.h
